<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\stm32_drv8301.ewp</path>
  </project>
  <batchBuild/>
</workspace>


